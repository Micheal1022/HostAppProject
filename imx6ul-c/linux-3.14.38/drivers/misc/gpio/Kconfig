## imx6ul-c/linux-3.14.38/drivers/misc/gpio/Kconfig
```kconfig
config GPIO_USER_INTF
	tristate "gpio user interface"
	---help---
	this driver for all gpio control
```
